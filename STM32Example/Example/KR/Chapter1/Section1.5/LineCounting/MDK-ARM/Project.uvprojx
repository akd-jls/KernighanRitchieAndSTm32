# Keil uVision project Project.uvprojx, settings and files
target STM32F4xx-Nucleo (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F401RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000,0x18000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F4xx-Nucleo
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F401xE,USE_STM32F4XX_NUCLEO, STDIN_ECHO, STDOUT_CR_LF, STDERR_CR_LF
  c misc: --C99
  c include: ..\Inc;..\..\..\..\..\..\STM32\common\Inc;..\..\..\..\..\..\STM32\Drivers\STM32F4xx_HAL_Driver\Inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  link misc: --diag_suppress=L6329
  group Example/LineCounting
    ../Src/: main.c
  group Doc
    ../: readme.md
  group STM32/MDK-ARM
    ./: startup_stm32f401xe.s
  group STM32/Drivers/CMSIS
    ../../../../../../STM32/common/Src/: system_stm32f4xx.c
software components: CMSIS:CORE 5.0.1, Compiler:I/O:STDIN 1.2.0, Compiler:I/O:STDOUT 1.2.0, Compiler:I/O:TTY 1.2.0
